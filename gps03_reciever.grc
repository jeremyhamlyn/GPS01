options:
  parameters:
    author: GPS01
    comment: |-
      GPS L1 C/A Receiver — HackRF Educational Flow Graph
      Frequency : 1575.42 MHz  (L1 = 154 × 10.23 MHz)
      Chip rate : 1.023 Mcps   (C/A Gold code)
      Sample rate: 4.092 MSPS  (4 samples/chip)
      Each block reflects one distinct mathematical operation.
    description: Receives GPS L1 C/A signal via HackRF and decodes latitude/longitude. Every DSP and navigation step is an individual block so the signal processing mathematics is fully visible in the flow graph.
    id: gps03_reciever
    output_language: python
    placement: ['0', '0']
    title: GPS03 — HackRF GPS L1 Receiver (Educational)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 4 × 1.023e6 = 4.092 MSPS — 4 samples per GPS C/A chip
    value: '4092000'
  states: {}
- name: gps_l1_freq
  id: variable
  parameters:
    comment: L1 = 154 × f0, where f0 = 10.23 MHz fundamental
    value: '1575420000'
  states: {}
- name: chip_rate
  id: variable
  parameters:
    comment: C/A chipping rate = f0 / 10 = 1.023 Mcps
    value: '1023000'
  states: {}
- name: code_len_samples
  id: variable
  parameters:
    comment: 1023 chips × 4 samp/chip = 4092 samples per 1 ms epoch
    value: '4092'
  states: {}
- name: sv_prn
  id: variable_qtgui_chooser
  parameters:
    comment: Active GPS satellite PRN to track (1-32)
    label: Satellite PRN
    num_opts: '8'
    option_labels: '[''PRN 1'',''PRN 2'',''PRN 3'',''PRN 4'',''PRN 5'',''PRN 6'',''PRN 7'',''PRN 8'']'
    options: '[1,2,3,4,5,6,7,8]'
    type: int
    value: '1'
  states: {}
- name: if_freq_hz
  id: variable_qtgui_range
  parameters:
    comment: Manual IF frequency offset trim (Hz)
    label: IF Offset (Hz)
    start: '-20000'
    stop: '20000'
    step: '50'
    value: '0'
  states: {}
- name: hackrf_lna_db
  id: variable_qtgui_range
  parameters:
    comment: HackRF LNA gain 0-40 dB in 8 dB steps
    label: LNA Gain (dB)
    rangeType: int
    start: '0'
    stop: '40'
    step: '8'
    value: '16'
  states: {}
- name: hackrf_vga_db
  id: variable_qtgui_range
  parameters:
    comment: HackRF VGA (baseband) gain 0-62 dB in 2 dB steps
    label: VGA Gain (dB)
    rangeType: int
    start: '0'
    stop: '62'
    step: '2'
    value: '16'
  states: {}
- name: hackrf_amp_enable
  id: variable_qtgui_check_box
  parameters:
    comment: HackRF RF amplifier +14 dB (use with care at GPS frequencies)
    label: RF Amp (+14 dB)
    type: int
    value: '0'
  states: {}
- name: rtlsdr_source_0
  id: osmosdr_source
  parameters:
    comment: |-
      STEP 1 — RF FRONT END
      Hardware: HackRF One
      Center freq: 1575.42 MHz (GPS L1)
      ADC: 8-bit I and Q → complex64 output
      LNA gain: 0-40 dB (8 dB steps)
      VGA gain: 0-62 dB (2 dB steps)
      RF amp: 0 or +14 dB
      GPS signal ≈ −20 dB below thermal noise
      kTB = 1.38e-23 × 290 × 4.09e6 ≈ −103 dBm  (noise floor)
    args: '''hackrf=0,bias=1'''
    bandwidth: '0'
    bb_gain: hackrf_vga_db
    freq: gps_l1_freq
    freq_corr: '0'
    gain: hackrf_amp_enable
    gain_mode: 'False'
    if_gain: hackrf_lna_db
    num_motherboards: '1'
    sample_rate: samp_rate
    type: fc32
  states: {}
- name: qtgui_freq_sink_rf
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: |-
      VISUALISATION — Raw RF spectrum at L1
      GPS L1 C/A occupies ±2.046 MHz around 1575.42 MHz
      (first null-to-null BW = 2 × chip_rate)
    fc: gps_l1_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: tabs@0:0,0,1,2
    label: RF Spectrum (L1)
    label1: GPS L1
    name: '"STEP 1: Raw RF @ 1575.42 MHz"'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    comment: |-
      STEP 2 — BANDLIMIT FILTER
      Math: H(f) = rect(f / 2·BW)   [ideal]
      FIR approximation with Kaiser window (β=6.76)
      h(n) = 2·BW·sinc(2·BW·n) × w_Kaiser(n)
      Convolution: y(t) = x(t) ∗ h(t)
      Cutoff = 2.046 MHz (= 2×chip_rate) — preserves C/A main lobe
      Transition BW = 500 kHz — removes adjacent channels
      Removes: interference, adjacent signals, and out-of-band noise
    decim: '1'
    gain: '1'
    cutoff_freq: '2046000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500000'
    win: window.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_filtered
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: |-
      VISUALISATION — Filtered GPS band
      After FIR: only C/A main lobe (±2 MHz) remains
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: tabs@0:1,0,1,2
    label: Filtered Spectrum
    label1: Filtered GPS L1
    name: '"STEP 2: Bandlimited (FIR, BW=2.046 MHz)"'
    type: complex
  states: {}
- name: analog_agc2_cc_0
  id: epy_block
  parameters:
    comment: |-
      STEP 3 — AUTOMATIC GAIN CONTROL (AGC)
      Math: y(n) = x(n) × g(n)
      g(n+1) = g(n) + rate·(ref − |y(n)|²)·g(n)
      Normalises amplitude so correlators see unit-power signal
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Automatic Gain Control."""

          def __init__(self, rate=0.001, reference=1.0, gain=1.0, max_gain=65536.0):
              gr.sync_block.__init__(self, name='AGC', in_sig=[np.complex64], out_sig=[np.complex64])
              self.rate = rate
              self.reference = reference
              self.gain = float(gain)
              self.max_gain = float(max_gain)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              g = self.gain
              for i in range(len(inp)):
                  y = inp[i] * g
                  out[i] = y
                  g += self.rate * (self.reference - abs(y) ** 2) * g
                  if g < 0.0:
                      g = 0.0
                  if g > self.max_gain:
                      g = self.max_gain
              self.gain = g
              return len(output_items[0])
    gain: '1.0'
    max_gain: '65536.0'
    rate: '1e-3'
    reference: '1.0'
  states: {}
- name: qtgui_time_sink_agc
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: |-
      VISUALISATION — AGC output I/Q samples
      Should show noise-like waveform at unit amplitude
    grid: 'True'
    gui_hint: tabs@1:0,0,1,2
    label1: I (Real)
    label2: Q (Imag)
    name: '"STEP 3: AGC-Normalised Signal"'
    size: '4092'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.5'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: epy_prn_generator
  id: epy_block
  parameters:
    comment: |-
      STEP 4 — PRN CODE GENERATOR (Gold Codes)
      Two 10-stage LFSRs combined via XOR:
      G1(x) = x¹° + x³ + 1           (feedback: taps 3, 10)
      G2(x) = x¹°+x⁹+x⁸+x⁶+x³+x²+1  (feedback: 2,3,6,8,9,10)
      C/A(n) = G1(n) ⊕ G2(n + phase_offset[sv])  mod 2
      Maps {0,1} → {+1,−1}, upsampled to 4 samp/chip
      Period = 1023 chips = 1 ms epoch
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """GPS C/A Gold Code Generator

          Two 10-stage Linear Feedback Shift Registers (LFSRs) whose XOR output
          produces a unique 1023-chip sequence for each GPS satellite PRN.

          Math:
              G1 polynomial:  x^10 + x^3 + 1          (feedback taps: 3, 10)
              G2 polynomial:  x^10+x^9+x^8+x^6+x^3+x^2+1 (feedback taps: 2,3,6,8,9,10)
              C/A(n) = G1(n) XOR G2((n + phase_offset[sv]) mod 1023)

          Output: complex64 stream of +1.0+0j / -1.0+0j chips, upsampled to
                  samp_rate / chip_rate samples per chip (4 samp/chip @ 4.092 MSPS).
          """

          # G2 phase assignments (chip delay per SV PRN 1..32)
          _G2_PHASE = [
              5,  6,  7,  8, 17, 18, 139, 140, 141, 251,
              252, 254, 255, 256, 257, 258, 469, 470, 471, 472,
              473, 474, 509, 512, 513, 514, 515, 516, 859, 860,
              861, 862
          ]

          def __init__(self, sv_prn=1, samp_rate=4092000, chip_rate=1023000):
              gr.sync_block.__init__(
                  self,
                  name='PRN Code Generator',
                  in_sig=None,
                  out_sig=[np.complex64]
              )
              self.sps = max(1, int(round(samp_rate / chip_rate)))  # samples per chip
              self._build_code(sv_prn)

          def _build_code(self, sv):
              """Generate full 1023-chip C/A code and upsample."""
              phase = self._G2_PHASE[(sv - 1) % 32]

              # Initialise both LFSRs to all-ones
              g1 = [1] * 10
              g2 = [1] * 10

              chips = np.empty(1023, dtype=np.float32)
              for i in range(1023):
                  g1_out = g1[9]                      # tap 10 (index 9)
                  g2_out = g2[(phase - 1) % 10]       # delayed tap
                  chips[i] = float(g1_out ^ g2_out)  # 0 or 1

                  # Advance G1: feedback = tap3 XOR tap10
                  g1_fb = g1[2] ^ g1[9]
                  g1 = [g1_fb] + g1[:-1]

                  # Advance G2: feedback = tap2^tap3^tap6^tap8^tap9^tap10
                  g2_fb = g2[1]^g2[2]^g2[5]^g2[7]^g2[8]^g2[9]
                  g2 = [g2_fb] + g2[:-1]

              # {0,1} -> {+1,-1}  then upsample to samp_rate
              bipolar = (1.0 - 2.0 * chips).astype(np.float32)
              upsampled = np.repeat(bipolar, self.sps)
              self._code = (upsampled + 0j).astype(np.complex64)
              self._len = len(self._code)   # = 4092 at 4.092 MSPS
              self._idx = 0

          def work(self, input_items, output_items):
              n = len(output_items[0])
              out = output_items[0]
              # Wrap-around indexing into the 1 ms code epoch
              for i in range(n):
                  out[i] = self._code[self._idx % self._len]
                  self._idx += 1
              return n
    sv_prn: sv_prn
    samp_rate: samp_rate
    chip_rate: chip_rate
  states: {}
- name: qtgui_time_sink_prn
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      VISUALISATION — Local PRN replica (1 epoch = 1 ms)
      Square wave ±1, chip width = 4 samples
    grid: 'True'
    gui_hint: tabs@1:1,0,1,2
    label1: PRN Chips
    name: '"STEP 4: PRN Gold Code (1 ms epoch)"'
    size: '4092'
    srate: samp_rate
    tr_delay: '0.0'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: blocks_multiply_cc_0
  id: epy_block
  parameters:
    comment: |-
      STEP 5 — CODE WIPE-OFF (Correlation)
      Math: z(n) = x(n) × c(n−τ)    [complex multiply]
      where x(n) = received signal (after AGC)
      c(n) = local PRN replica (±1, from Step 4)
      When code phase τ matches received code: signal despreads
      to a narrowband 50 bps BPSK nav message signal.
      When τ does not match: output remains wideband noise.
      BPSK despreading gain = 10·log10(1023) ≈ 30 dB
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Element-wise complex multiply."""

          def __init__(self):
              gr.sync_block.__init__(self, name='Multiply', in_sig=[np.complex64, np.complex64], out_sig=[np.complex64])

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0] * input_items[1]
              return len(output_items[0])
  states: {}
- name: blocks_integrate_cc_0
  id: epy_block
  parameters:
    comment: |-
      STEP 6 — COHERENT INTEGRATION (Integrate & Dump)
      Math: I(k) = Σ[n=0..N-1] z(n + k·N)    where N = code_len_samples
      Equivalent to a matched filter for the PRN code:
      I = Σ Re[z(n)]   (in-phase  component)
      Q = Σ Im[z(n)]   (quadrature component)
      Integration length N = 4092 samples = 1 ms epoch
      SNR improvement = 10·log10(N) ≈ 36 dB
      Output rate = 1000 correlation values/second
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Coherent Integrate & Dump (epoch accumulator, full-rate output)."""

          def __init__(self, decim=4092):
              gr.sync_block.__init__(self, name='Integrate & Dump', in_sig=[np.complex64], out_sig=[np.complex64])
              self.decim = int(decim)
              self._accum = np.complex64(0)
              self._last = np.complex64(0)
              self._count = 0

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n = len(inp)
              for i in range(n):
                  self._accum += inp[i]
                  self._count += 1
                  if self._count >= self.decim:
                      self._last = self._accum
                      self._accum = np.complex64(0)
                      self._count = 0
                  out[i] = self._last
              return n
    decim: code_len_samples
  states: {}
- name: epy_acquisition
  id: epy_block
  parameters:
    comment: |-
      STEP 7 — SIGNAL ACQUISITION (FFT Parallel Search)
      Searches code phase (0..1022 chips) AND Doppler (±10 kHz) simultaneously.
      Math:
      For each Doppler hypothesis f_D:
      x_d(n) = x(n) × e^{-j2π f_D n / f_s}       [carrier wipe-off]
      R(τ, f_D) = IFFT{ FFT(x_d) × conj(FFT(c)) } [circular correlation]
      |R(τ, f_D)|² = cross-correlation power surface
      Peak detection: (τ*, f_D*) = argmax |R(τ, f_D)|²
      Threshold: peak / mean > 2.5  (declared acquired)
      Output: code_phase (samples), doppler_freq (Hz), C/N0 estimate
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """GPS Signal Acquisition Engine

          Uses FFT-based circular correlation to search simultaneously over:
            - Code phase : 0 .. 1022 chips (= 4092 samples at 4 samp/chip)
            - Doppler     : -10 kHz .. +10 kHz in 500 Hz steps

          Math (per Doppler bin f_D):
              x_d(n)      = x(n) * exp(-j*2*pi*f_D*n/fs)          carrier wipe-off
              R(tau, f_D) = IFFT{ FFT(x_d) * conj(FFT(c)) }    circular cross-correlation
              Peak = argmax |R(tau, f_D)|^2                        best code/freq match
              CN0_est = 10*log10(peak_power / noise_floor / T_coh)   C/N0 estimate

          Outputs scalar float stream: [code_phase_samp, doppler_hz, cn0_db]
          packed as a 3-element repeating sequence.
          """

          def __init__(self, samp_rate=4092000, chip_rate=1023000, sv_prn=1):
              gr.sync_block.__init__(
                  self,
                  name='Acquisition Engine',
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )
              self.fs = samp_rate
              self.N  = int(round(samp_rate / chip_rate)) * 1023  # 4092 samples
              self.doppler_range = np.arange(-10000, 10001, 500, dtype=np.float32)
              self._prn_fft = np.conj(np.fft.fft(self._ca_code(sv_prn, samp_rate, chip_rate)))
              self.set_output_multiple(3)

          def _ca_code(self, sv, fs, fc):
              g2p = [5,6,7,8,17,18,139,140,141,251,252,254,255,256,
                     257,258,469,470,471,472,473,474,509,512,513,514,
                     515,516,859,860,861,862]
              phase = g2p[(sv-1)%32]
              g1 = g2 = [1]*10
              chips = np.empty(1023, dtype=np.float32)
              for i in range(1023):
                  chips[i] = float(g1[9] ^ g2[(phase-1)%10])
                  g1_fb = g1[2]^g1[9]; g1 = [g1_fb]+g1[:-1]
                  g2_fb = g2[1]^g2[2]^g2[5]^g2[7]^g2[8]^g2[9]; g2 = [g2_fb]+g2[:-1]
              return np.repeat(1.0-2.0*chips, int(round(fs/fc))).astype(np.complex64)

          def work(self, input_items, output_items):
              x = input_items[0]
              if len(x) < self.N:
                  return 0
              epoch = x[:self.N]
              n = np.arange(self.N, dtype=np.float64)
              best_pow, best_tau, best_fd = 0.0, 0, 0.0
              for fd in self.doppler_range:
                  # Carrier wipe-off for this Doppler hypothesis
                  wipeoff = epoch * np.exp(-1j * 2.0 * np.pi * fd * n / self.fs).astype(np.complex64)
                  corr = np.abs(np.fft.ifft(np.fft.fft(wipeoff) * self._prn_fft))**2
                  pk = corr.max()
                  if pk > best_pow:
                      best_pow = pk
                      best_tau = int(corr.argmax())
                      best_fd  = float(fd)
              noise = (best_pow - best_pow/len(epoch)) / len(epoch) + 1e-30
              cn0 = float(10.0 * np.log10(best_pow / noise / 0.001))
              out = output_items[0]
              out[0] = float(best_tau)
              out[1] = best_fd
              out[2] = cn0
              return 3
    samp_rate: samp_rate
    chip_rate: chip_rate
    sv_prn: sv_prn
  states: {}
- name: epy_costas_pll
  id: epy_block
  parameters:
    comment: |-
      STEP 8 — CARRIER TRACKING (Costas PLL)
      Removes residual carrier and Doppler shift after acquisition.
      Math:
      NCO: φ(n+1) = φ(n) + 2π·f_nco/f_s     [phase accumulator]
      Mix: y(n) = x(n) × e^{-jφ(n)}              [carrier wipe-off]
      Phase discriminator (Costas): e(n) = Im[y(n)] × Re[y(n)]
      = sign(I) × Q  for BPSK
      (insensitive to data bit sign — Costas loop property)
      Loop filter (2nd order):
      v(n) = K1·e(n) + K2·Σe(k)    [proportional + integral]
      f_nco(n+1) = f_nco(n) + v(n)          [NCO update]
      Bandwidth BL ≈ 18 Hz (typical GPS PLL)
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Second-order Costas PLL — GPS Carrier Tracking

          Tracks the residual carrier and Doppler after acquisition.
          Uses an I/Q Costas phase discriminator that is insensitive to
          the ±180-degree data bit transitions (BPSK on 50 bps nav message).

          Loop equations (2nd-order PLL):
              e(n)   = Im(y) * Re(y)   / (|y|^2 + eps)   [normalised Costas error]
              v(n)   = K1*e(n) + K2*integral(e)          [loop filter]
              phi(n) = phi(n-1) + 2*pi*v(n)/fs                [phase update]
              y(n)   = x(n) * exp(-j*phi(n))                  [wipe-off]
          """

          def __init__(self, fs=4092000, bw_hz=18.0):
              gr.sync_block.__init__(
                  self,
                  name='Costas PLL (Carrier Tracking)',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # 2nd-order loop gains from natural frequency
              omega_n = 2.0 * np.pi * bw_hz
              zeta   = 0.707          # critically damped
              T      = 1.0 / fs
              self.K1 = 2.0 * zeta * omega_n * T     # proportional gain
              self.K2 = omega_n**2 * T**2             # integral gain
              self._phi     = 0.0
              self._int_err = 0.0

          def work(self, input_items, output_items):
              x   = input_items[0]
              out = output_items[0]
              n   = len(x)
              phi     = self._phi
              int_err = self._int_err
              K1, K2  = self.K1, self.K2
              tw_pi_over_fs = 2.0 * np.pi  # pre-factor; phase update is v(n)
              for i in range(n):
                  # Wipe off current NCO phase
                  y = x[i] * np.exp(-1j * phi)
                  # Costas discriminator: e = Im(y)*Re(y) / (|y|^2 + 1e-10)
                  I, Q = float(y.real), float(y.imag)
                  mag2 = I*I + Q*Q + 1e-10
                  e = (I * Q) / mag2
                  # Loop filter (proportional + integral)
                  int_err += K2 * e
                  v = K1 * e + int_err
                  # Phase accumulator
                  phi += v
                  out[i] = np.complex64(y)
              self._phi     = phi
              self._int_err = int_err
              return n
    fs: samp_rate
    bw_hz: '18.0'
  states: {}
- name: epy_dll
  id: epy_block
  parameters:
    comment: |-
      STEP 9 — CODE TRACKING (Delay-Locked Loop, DLL)
      Keeps the local PRN replica aligned with the received code.
      Uses an early-minus-late (EML) envelope discriminator.
      Math:
      Early  replica: c_E(n) = c(n + Δ/2)   [Δ = 1 chip early]
      Prompt replica: c_P(n) = c(n)            [on-time]
      Late   replica: c_L(n) = c(n − Δ/2)   [Δ = 1 chip late]
      Correlate each against x(n) over 1 ms:
      E = Σ x(n)·c_E(n),  L = Σ x(n)·c_L(n)
      EML discriminator: ε(τ) = (|E|² − |L|²) / (|E|² + |L|²)
      Code phase update: τ(k+1) = τ(k) + K_dll · ε(τ)
      Bandwidth BL ≈ 1 Hz (narrow — thermal noise vs. dynamics)
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Early-Minus-Late (EML) Delay-Locked Loop

          Tracks the C/A code phase to maintain correlation peak alignment.

          Math:
              Early / Late correlators at ±0.5 chip spacing:
                  R_E(tau) = sum( x(n) * c(n - tau + T_c/2) )   over 1 ms
                  R_L(tau) = sum( x(n) * c(n - tau - T_c/2) )   over 1 ms

              EML normalised discriminator:
                  eps(tau) = (|R_E|^2 - |R_L|^2) / (|R_E|^2 + |R_L|^2)

              First-order loop update:
                  tau(k+1) = tau(k) + K_dll * eps(tau_k)

              K_dll chosen for BL ~ 1 Hz.
          Output port 0: complex (prompt correlator I+jQ for nav bits)
          Output port 1: float  (code phase in chips for pseudorange)
          """

          _G2_PHASE = [
              5,6,7,8,17,18,139,140,141,251,252,254,255,256,
              257,258,469,470,471,472,473,474,509,512,513,514,
              515,516,859,860,861,862
          ]

          def __init__(self, fs=4092000, chip_rate=1023000, sv_prn=1):
              gr.sync_block.__init__(
                  self,
                  name='DLL Code Tracking',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.float32]
              )
              self.sps  = int(round(fs / chip_rate))  # 4 samples/chip
              self.N    = self.sps * 1023              # samples per epoch
              self.K    = 0.001                        # DLL gain
              self.tau  = 0.0                          # code phase (chips)
              self._code = self._gen_code(sv_prn, fs, chip_rate)
              self.set_output_multiple(3)
              self._buf = np.zeros(0, dtype=np.complex64)

          def _gen_code(self, sv, fs, fc):
              ph = self._G2_PHASE[(sv-1)%32]
              g1 = g2 = [1]*10
              chips = np.empty(1023, dtype=np.float32)
              for i in range(1023):
                  chips[i] = float(g1[9]^g2[(ph-1)%10])
                  g1=[g1[2]^g1[9]]+g1[:-1]; g2=[g2[1]^g2[2]^g2[5]^g2[7]^g2[8]^g2[9]]+g2[:-1]
              sps = int(round(fs / fc))
              return np.tile(np.repeat(1.0-2.0*chips, sps), 3).astype(np.float32)  # 3 periods for wrapping

          def work(self, input_items, output_items):
              self._buf = np.concatenate([self._buf, input_items[0]])
              if len(self._buf) < self.N:
                  return len(input_items[0])
              epoch = self._buf[:self.N]
              self._buf = self._buf[self.N:]
              sps = self.sps
              tau_samp = int(round(self.tau * sps)) % self.N
              half = sps // 2
              # Roll code to align with current code phase estimate
              c = np.roll(self._code[:self.N], tau_samp)
              c_E = np.roll(self._code[:self.N], tau_samp + half)
              c_L = np.roll(self._code[:self.N], tau_samp - half)
              # Correlate (1 ms coherent integration)
              R_P = np.dot(epoch, c)
              R_E = np.dot(epoch, c_E)
              R_L = np.dot(epoch, c_L)
              # EML discriminator
              e2, l2 = abs(R_E)**2, abs(R_L)**2
              eps = (e2 - l2) / (e2 + l2 + 1e-10)
              self.tau -= self.K * eps
              out0, out1 = output_items[0], output_items[1]
              out0[0] = np.complex64(R_P)
              out1[0] = np.float32(self.tau % 1023.0)
              return 1
    fs: samp_rate
    chip_rate: chip_rate
    sv_prn: sv_prn
  states: {}
- name: epy_nav_bit_decoder
  id: epy_block
  parameters:
    comment: |-
      STEP 10 — NAVIGATION BIT DETECTOR (50 bps)
      Integrates prompt correlator output over 20 ms (20 epochs) to
      detect each 20 ms navigation bit.
      Math:
      For each 20-epoch window:
      B_k = sign(Σ[i=0..19] Re[R_P(k·20 + i)])  [coherent bit integration]
      Carrier phase ambiguity — tracked by Costas loop (Step 8)
      means sign is correct only after lock.
      Bit sync detection: cross-correlation of 20-epoch accumulations
      peaks at the correct epoch boundary.
      Output: integer bit stream {+1, −1} at 50 bits/second
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """GPS Navigation Bit Detector

          Each GPS navigation data bit lasts 20 ms = 20 C/A code epochs.
          This block accumulates prompt correlator outputs (1 per ms from the DLL)
          over 20 samples and decides the bit sign.

          Math:
              I_acc(k) = sum_{i=0}^{19} Re[ R_P(20*k + i) ]   coherent integration
              bit(k)   = sign( I_acc(k) )                       hard decision

          An initial bit-sync search tries all 20 possible epoch boundaries
          and selects the one that maximises |I_acc| variance.
          """

          BITS_PER_WORD = 20   # 20 ms per navigation bit

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Nav Bit Detector (50 bps)',
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )
              self.set_output_multiple(1)
              self._buf = []
              self._boundary = None   # epoch offset of bit boundary
              self._sync_buf = []     # for bit-sync search

          def _find_boundary(self, buf):
              """Try all 20 epoch offsets; pick the one with max |I_acc| variance."""
              scores = np.zeros(self.BITS_PER_WORD)
              data = np.array([x.real for x in buf[:400]], dtype=np.float32)  # 20 bits worth
              for offset in range(self.BITS_PER_WORD):
                  accs = []
                  for b in range(20):
                      start = offset + b * self.BITS_PER_WORD
                      if start + self.BITS_PER_WORD <= len(data):
                          accs.append(data[start:start+self.BITS_PER_WORD].sum())
                  scores[offset] = np.var(accs) if len(accs) > 1 else 0.0
              return int(np.argmax(scores))

          def work(self, input_items, output_items):
              self._buf.extend(input_items[0].tolist())
              out = output_items[0]
              n_out = 0
              # Bit-sync: collect 400 epochs then find boundary
              if self._boundary is None:
                  if len(self._sync_buf) < 400:
                      self._sync_buf.extend(input_items[0].tolist())
                  else:
                      self._boundary = self._find_boundary(self._sync_buf)
                      self._buf = self._sync_buf[self._boundary:]
              else:
                  while len(self._buf) >= self.BITS_PER_WORD:
                      chunk = self._buf[:self.BITS_PER_WORD]
                      self._buf = self._buf[self.BITS_PER_WORD:]
                      acc = sum(x.real for x in chunk)
                      if n_out < len(out):
                          out[n_out] = np.float32(1.0 if acc >= 0 else -1.0)
                          n_out += 1
              return max(n_out, 0)
  states: {}
- name: epy_nav_message_parser
  id: epy_block
  parameters:
    comment: |-
      STEP 11 — NAVIGATION MESSAGE PARSER
      Decodes the 1500-bit GPS navigation message (30 s period).
      Structure:
      1 frame    = 5 subframes × 300 bits  (30 s)
      1 subframe = 10 words    × 30 bits   (6 s)
      1 word     = 24 data bits + 6 parity (BCH)
      Parity check: d_26..d_30 = BCH(d_1..d_24, D_29*, D_30*)
      Subframe 1: Week number, clock corrections (a_f0, a_f1, a_f2)
      Subframe 2: Ephemeris  (M_0, e, sqrt_A, t_oe, C_uc, C_us)
      Subframe 3: Ephemeris  (i_0, OMEGA_0, omega, IDOT, OMEGADOT)
      Subframe 4/5: Almanac & UTC corrections
      Output: JSON-encoded ephemeris dict per satellite
    _source_code: |
      import numpy as np
      from gnuradio import gr


      GPS_PARITY_MATRIX = [
          0b111011010000000000000000,
          0b011101101000000000000000,
          0b101110110100000000000000,
          0b010111011010000000000000,
          0b101011101101000000000000,
          0b110101110110100000000000,
      ]


      def parity_check(word_30):
          """GPS 6-bit BCH parity check on 30-bit word."""
          d = word_30 >> 6  # 24 data bits
          prev = (word_30 >> 30) & 0x3  # D29*, D30* from previous word
          ok = True
          for i, mask in enumerate(GPS_PARITY_MATRIX):
              p_calc = bin(d & mask).count('1') & 1
              p_recv = (word_30 >> (5 - i)) & 1
              if p_calc != p_recv:
                  ok = False
          return ok


      class blk(gr.sync_block):
          """GPS Navigation Message Parser

          Accumulates the 50 bps bit stream, synchronises to the preamble
          (0x8B = 10001011), and decodes navigation subframes.

          Subframe structure (each 300 bits @ 50 bps = 6 s):
              Word 1 : TLM  — preamble 10001011, TLM message, reserved, parity
              Word 2 : HOW  — TOW count, subframe ID (bits 20-22), parity
              Words 3-10: data payload (subframe-dependent)

          Outputs message PDU with ephemeris dict (JSON bytes).
          """

          PREAMBLE = 0b10001011   # 0x8B
          SUBFRAME_BITS = 300

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Nav Message Parser',
                  in_sig=[np.float32],
                  out_sig=[]
              )
              self.message_port_register_out(gr.pmt.intern('ephemeris'))
              self._bits = []
              self._ephemeris = {}

          def _bits_to_int(self, bits, start, length):
              val = 0
              for i in range(length):
                  val = (val << 1) | (1 if bits[start + i] > 0 else 0)
              return val

          def _twos_complement(self, val, bits):
              if val & (1 << (bits - 1)):
                  val -= (1 << bits)
              return val

          def _decode_subframe(self, bits):
              """Extract key fields from 300-bit subframe."""
              sf_id = self._bits_to_int(bits, 49, 3)  # Word 2 bits 20-22
              import json
              if sf_id == 1:
                  week  = self._bits_to_int(bits, 60, 10)
                  a_f2  = self._twos_complement(self._bits_to_int(bits, 180, 8), 8)  * 2**-55
                  a_f1  = self._twos_complement(self._bits_to_int(bits, 188, 16), 16) * 2**-43
                  a_f0  = self._twos_complement(self._bits_to_int(bits, 204, 22), 22) * 2**-31
                  self._ephemeris.update({'week': week, 'af0': a_f0, 'af1': a_f1, 'af2': a_f2})
              elif sf_id == 2:
                  sqrtA = self._bits_to_int(bits, 150, 32) * 2**-19
                  e     = self._bits_to_int(bits, 120, 32) * 2**-33
                  M0    = self._twos_complement(self._bits_to_int(bits, 90, 32), 32) * 2**-31 * 3.141592653589793
                  self._ephemeris.update({'sqrtA': sqrtA, 'e': e, 'M0': M0})
              elif sf_id == 3:
                  i0  = self._twos_complement(self._bits_to_int(bits, 150, 32), 32) * 2**-31 * 3.141592653589793
                  om0 = self._twos_complement(self._bits_to_int(bits, 90, 32), 32)  * 2**-31 * 3.141592653589793
                  self._ephemeris.update({'i0': i0, 'Omega0': om0})
              if len(self._ephemeris) >= 8:
                  pdu = gr.pmt.cons(gr.pmt.intern('ephemeris'),
                                   gr.pmt.init_u8vector(len(json.dumps(self._ephemeris).encode()),
                                   list(json.dumps(self._ephemeris).encode())))
                  self.message_port_pub(gr.pmt.intern('ephemeris'), pdu)

          def work(self, input_items, output_items):
              self._bits.extend(input_items[0].tolist())
              # Search for preamble (0x8B) with 300-bit alignment
              while len(self._bits) >= self.SUBFRAME_BITS:
                  # Check for preamble in first 8 bits
                  first8 = self._bits_to_int(self._bits, 0, 8)
                  if first8 == self.PREAMBLE or first8 == (~self.PREAMBLE & 0xFF):
                      self._decode_subframe(self._bits)
                      self._bits = self._bits[self.SUBFRAME_BITS:]
                  else:
                      self._bits.pop(0)
              return len(input_items[0])
  states: {}
- name: epy_pseudorange_calc
  id: epy_block
  parameters:
    comment: |-
      STEP 12 — PSEUDORANGE CALCULATOR
      Converts code phase and time-of-week into a range measurement.
      Math:
      Transmission time: t_tx = TOW + code_phase / chip_rate
      Reception  time:   t_rx = local clock time
      Raw pseudorange:   ρ = c × (t_rx − t_tx)
      where c = 299,792,458 m/s (speed of light)
      Satellite position at t_tx (Kepler orbit propagation):
      Mean anomaly: M = M_0 + n·(t − t_oe)
      n = sqrt(μ / a³)   [μ = 3.986004418e14 m³/s²]
      Eccentric anomaly: solve Kepler eq. M = E − e·sin(E)
      True anomaly: ν = atan2(sqrt(1−e²)·sin(E), cos(E)−e)
      Satellite ECEF XYZ from orbital elements.
      Geometric range: ρ_geo = |x_sv − x_rx|
      Residual: δρ = ρ − ρ_geo  [for least squares]
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import json


      MU_EARTH  = 3.986004418e14   # m^3/s^2  (GM)
      OMEGA_E   = 7.2921151467e-5  # rad/s   (Earth rotation rate)
      C_LIGHT   = 299792458.0       # m/s
      PI        = 3.141592653589793


      def kepler_solve(M, e, tol=1e-12):
          """Solve Kepler's equation M = E - e*sin(E) by Newton-Raphson."""
          E = M
          for _ in range(10):
              dE = (M - E + e * np.sin(E)) / (1.0 - e * np.cos(E))
              E += dE
              if abs(dE) < tol:
                  break
          return E


      def sv_position_ecef(eph, t):
          """
          Propagate satellite ECEF position from Keplerian ephemeris.
          eph: dict with keys sqrtA, e, M0, i0, Omega0, (af0, af1, week, ...)
          t  : time of applicability (GPS seconds of week)
          """
          A  = eph['sqrtA']**2              # semi-major axis (m)
          n0 = np.sqrt(MU_EARTH / A**3)       # mean motion (rad/s)
          tk = t - eph.get('toe', 0.0)        # time from ephemeris reference
          n  = n0                             # (simplified: no delta-n correction)
          M  = eph['M0'] + n * tk             # mean anomaly
          E  = kepler_solve(M, eph['e'])      # eccentric anomaly
          sinv = np.sqrt(1.0 - eph['e']**2) * np.sin(E) / (1.0 - eph['e'] * np.cos(E))
          cosv = (np.cos(E) - eph['e']) / (1.0 - eph['e'] * np.cos(E))
          nu   = np.arctan2(sinv, cosv)          # true anomaly
          r    = A * (1.0 - eph['e'] * np.cos(E))  # orbital radius
          # Orbital plane x, y
          xp   = r * np.cos(nu)
          yp   = r * np.sin(nu)
          # Inclination and RAAN (right ascension of ascending node)
          i    = eph.get('i0', 0.0)
          Om   = eph.get('Omega0', 0.0) - OMEGA_E * t   # correct for Earth rotation
          # Rotate to ECEF
          X = xp * np.cos(Om) - yp * np.cos(i) * np.sin(Om)
          Y = xp * np.sin(Om) + yp * np.cos(i) * np.cos(Om)
          Z = yp * np.sin(i)
          return np.array([X, Y, Z])


      class blk(gr.sync_block):
          """Pseudorange Calculator

          Receives:
            - Ephemeris message from Nav Message Parser (Step 11)
            - Code phase float stream from DLL (Step 9)

          Computes:
              rho = c * (t_rx - t_tx)         raw pseudorange in metres
              sv_xyz = Keplerian orbit propagation to get satellite ECEF position

          Outputs message: {prn, rho, sv_xyz, t_rx}
          """

          def __init__(self, sv_prn=1):
              gr.sync_block.__init__(
                  self,
                  name='Pseudorange Calculator',
                  in_sig=[np.float32],
                  out_sig=[]
              )
              self.sv_prn = sv_prn
              self.message_port_register_in(gr.pmt.intern('ephemeris'))
              self.message_port_register_out(gr.pmt.intern('pseudorange'))
              self.set_msg_handler(gr.pmt.intern('ephemeris'), self._handle_eph)
              self._eph = None
              self._tow = 0.0

          def _handle_eph(self, msg):
              data = bytes(gr.pmt.u8vector_elements(gr.pmt.cdr(msg)))
              self._eph = json.loads(data.decode())

          def work(self, input_items, output_items):
              code_phases = input_items[0]
              if self._eph is None:
                  return len(code_phases)
              for cp in code_phases:
                  # Pseudorange: c * code_phase_in_seconds
                  chip_period = 1.0 / 1023000.0   # seconds per chip
                  t_prop = float(cp) * chip_period
                  rho = C_LIGHT * t_prop
                  # Satellite ECEF position
                  sv_xyz = sv_position_ecef(self._eph, self._tow + t_prop).tolist()
                  self._tow += chip_period
                  result = {'prn': self.sv_prn, 'rho': rho, 'sv_xyz': sv_xyz}
                  pdu = gr.pmt.cons(
                      gr.pmt.intern('pseudorange'),
                      gr.pmt.init_u8vector(len(json.dumps(result).encode()),
                      list(json.dumps(result).encode())))
                  self.message_port_pub(gr.pmt.intern('pseudorange'), pdu)
              return len(code_phases)
    sv_prn: sv_prn
  states: {}
- name: epy_position_solver
  id: epy_block
  parameters:
    comment: |-
      STEP 13 — POSITION SOLVER (WGS-84 Least Squares)
      Solves for receiver position (X,Y,Z) and clock bias (b) from
      ≥4 satellite pseudoranges simultaneously.
      Math:
      State vector: x = [X_r, Y_r, Z_r, b]^T
      Predicted range: ρ̂_i = |sv_xyz_i − [X_r,Y_r,Z_r]| + b
      Linearise around estimate x_0:
      Δρ_i = ρ_i − ρ̂_i    [range residual]
      Line-of-sight unit vector:
      a_i = (x_0 − sv_xyz_i) / |ρ̂_i|
      Geometry matrix H (n×4): [a_ix, a_iy, a_iz, 1]  (per satellite)
      Least squares update:
      Δx = (H^T H)^{-1} H^T Δρ    [normal equations]
      Iterate until |Δx| < 1 m
      Convert ECEF (X,Y,Z) → WGS-84 (lat, lon, alt):
      lat = atan2(Z + e²b sinφ, p)  [iterative Bowring]
      lon = atan2(Y, X)
      alt = p/cos(lat) − N  [N = WGS-84 prime vertical radius]
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import json


      C_LIGHT = 299792458.0
      PI      = 3.141592653589793
      # WGS-84 ellipsoid constants
      WGS84_A = 6378137.0          # semi-major axis (m)
      WGS84_B = 6356752.3142      # semi-minor axis (m)
      WGS84_E2 = 1.0 - (WGS84_B/WGS84_A)**2  # first eccentricity squared


      def ecef_to_geodetic(X, Y, Z):
          """
          Convert ECEF (X, Y, Z) metres to WGS-84 (lat deg, lon deg, alt m)
          using iterative Bowring method.
          """
          p   = np.sqrt(X**2 + Y**2)
          lon = np.arctan2(Y, X)
          lat = np.arctan2(Z, p * (1.0 - WGS84_E2))  # initial estimate
          for _ in range(10):
              sin_lat = np.sin(lat)
              N   = WGS84_A / np.sqrt(1.0 - WGS84_E2 * sin_lat**2)
              lat_new = np.arctan2(Z + WGS84_E2 * N * sin_lat, p)
              if abs(lat_new - lat) < 1e-12:
                  lat = lat_new
                  break
              lat = lat_new
          sin_lat = np.sin(lat)
          N   = WGS84_A / np.sqrt(1.0 - WGS84_E2 * sin_lat**2)
          alt = p / np.cos(lat) - N if abs(np.cos(lat)) > 1e-10 else abs(Z) / np.sin(lat) - N * (1.0 - WGS84_E2)
          return np.degrees(lat), np.degrees(lon), alt


      def solve_ls(pseudoranges):
          """
          Iterative least-squares position fix.
          pseudoranges: list of {'prn', 'rho', 'sv_xyz'}
          Returns (lat, lon, alt) in degrees / metres, or None if underdetermined.
          """
          if len(pseudoranges) < 4:
              return None
          # Initial estimate: Earth centre, zero clock bias
          x = np.array([0.0, 0.0, 0.0, 0.0])  # [X, Y, Z, b]
          for iteration in range(10):
              H_rows, delta_rho = [], []
              for pr in pseudoranges:
                  sv  = np.array(pr['sv_xyz'])
                  diff = x[:3] - sv
                  rho_hat = np.linalg.norm(diff) + x[3]
                  if rho_hat < 1.0:
                      rho_hat = 1.0  # guard
                  los = diff / (rho_hat - x[3] + 1e-10)   # unit vector receiver -> SV
                  H_rows.append([los[0], los[1], los[2], 1.0])
                  delta_rho.append(pr['rho'] - rho_hat)
              H  = np.array(H_rows)
              dr = np.array(delta_rho)
              # Normal equations: dx = (H^T H)^-1 H^T dr
              try:
                  dx = np.linalg.solve(H.T @ H, H.T @ dr)
              except np.linalg.LinAlgError:
                  return None
              x += dx
              if np.linalg.norm(dx[:3]) < 0.01:   # 1 cm convergence
                  break
          lat, lon, alt = ecef_to_geodetic(x[0], x[1], x[2])
          return {'lat': lat, 'lon': lon, 'alt_m': alt, 'clock_bias_m': float(x[3])}


      class blk(gr.sync_block):
          """WGS-84 Iterative Least-Squares Position Solver

          Accumulates pseudorange measurements from multiple satellites
          (Step 12) and runs the iterative LS fix when >=4 are available.

          Algorithm:
              1. Build geometry matrix H (n x 4)
              2. Compute predicted ranges rho_hat from current estimate
              3. Form residual vector dr = rho_measured - rho_hat
              4. Update: dx = (H^T H)^-1 H^T dr  (normal equations)
              5. Repeat until ||dx|| < 0.01 m
              6. Convert ECEF -> WGS-84 geodetic (lat/lon/alt)
          """

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Position Solver (WGS-84 LS)',
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(gr.pmt.intern('pseudorange'))
              self.message_port_register_out(gr.pmt.intern('position'))
              self.set_msg_handler(gr.pmt.intern('pseudorange'), self._handle_pr)
              self._measurements = {}   # {prn: last pseudorange dict}

          def _handle_pr(self, msg):
              data = bytes(gr.pmt.u8vector_elements(gr.pmt.cdr(msg)))
              pr = json.loads(data.decode())
              self._measurements[pr['prn']] = pr
              if len(self._measurements) >= 4:
                  fix = solve_ls(list(self._measurements.values()))
                  if fix:
                      out_bytes = json.dumps(fix).encode()
                      pdu = gr.pmt.cons(
                          gr.pmt.intern('position'),
                          gr.pmt.init_u8vector(len(out_bytes), list(out_bytes)))
                      self.message_port_pub(gr.pmt.intern('position'), pdu)

          def work(self, input_items, output_items):
              return 0
  states: {}
- name: epy_nmea_encoder
  id: epy_block
  parameters:
    comment: |-
      STEP 14 — NMEA 0183 ENCODER
      Converts WGS-84 position fix to NMEA $GPGGA sentence.
      Format:
      $GPGGA,HHMMSS.ss,DDMM.mmm,N,DDDMM.mmm,E,Q,NN,DOP,ALT,M,,,,*CS<CR><LF>
      Fields:
      HHMMSS.ss — UTC time (from GPS week + TOW + leap seconds)
      DDMM.mmm  — Latitude in degrees + decimal minutes (NMEA units)
      DDDMM.mmm — Longitude
      Q         — Fix quality: 1=GPS, 2=DGPS
      NN        — Number of satellites used
      DOP       — Horizontal dilution of precision (HDOP)
      ALT,M     — MSL altitude in metres
      *CS       — XOR checksum of all chars between $ and *
      Also writes $GPRMC sentence for compatibility.
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import json
      import time


      def nmea_checksum(sentence):
          """XOR all characters between '$' and '*'."""
          cs = 0
          for ch in sentence:
              cs ^= ord(ch)
          return '{:02X}'.format(cs)


      def deg_to_nmea(deg, is_lat):
          """Convert decimal degrees to NMEA DDDMM.mmmm format + hemisphere."""
          hemi = ('N' if deg >= 0 else 'S') if is_lat else ('E' if deg >= 0 else 'W')
          deg = abs(deg)
          d = int(deg)
          m = (deg - d) * 60.0
          fmt = '{:02d}{:09.6f}' if is_lat else '{:03d}{:09.6f}'
          return fmt.format(d, m), hemi


      class blk(gr.sync_block):
          """NMEA 0183 Sentence Encoder

          Receives position fix messages from the Position Solver (Step 13)
          and outputs standard NMEA 0183 $GPGGA and $GPRMC sentences.

          $GPGGA — Global Positioning System Fix Data
          $GPRMC — Recommended Minimum Specific GPS Data

          Both sentences include XOR checksum for data integrity.
          Output is PDU message containing ASCII NMEA bytes.
          """

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='NMEA 0183 Encoder',
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(gr.pmt.intern('position'))
              self.message_port_register_out(gr.pmt.intern('nmea'))
              self.set_msg_handler(gr.pmt.intern('position'), self._handle_pos)
              self._fix_count = 0

          def _handle_pos(self, msg):
              data = bytes(gr.pmt.u8vector_elements(gr.pmt.cdr(msg)))
              pos  = json.loads(data.decode())
              lat, lon, alt = pos['lat'], pos['lon'], pos['alt_m']
              self._fix_count += 1

              # UTC time from system clock (approximate — proper impl uses GPS TOW)
              t   = time.gmtime()
              utc = '{:02d}{:02d}{:02d}.00'.format(t.tm_hour, t.tm_min, t.tm_sec)
              date = '{:02d}{:02d}{:02d}'.format(t.tm_mday, t.tm_mon, t.tm_year % 100)

              lat_s, lat_h = deg_to_nmea(lat, is_lat=True)
              lon_s, lon_h = deg_to_nmea(lon, is_lat=False)

              # $GPGGA
              gga_body = 'GPGGA,{},{},{},{},{},1,04,1.0,{:.1f},M,0.0,M,,'.format(
                  utc, lat_s, lat_h, lon_s, lon_h, alt)
              gga = '${}*{}\r\n'.format(gga_body, nmea_checksum(gga_body))

              # $GPRMC
              rmc_body = 'GPRMC,{},A,{},{},{},{},{:.1f},{:.1f},{},,,A'.format(
                  utc, lat_s, lat_h, lon_s, lon_h,
                  0.0,   # speed over ground (knots) — placeholder
                  0.0,   # track angle — placeholder
                  date)
              rmc = '${}*{}\r\n'.format(rmc_body, nmea_checksum(rmc_body))

              combined = (gga + rmc).encode('ascii')
              pdu = gr.pmt.cons(
                  gr.pmt.intern('nmea'),
                  gr.pmt.init_u8vector(len(combined), list(combined)))
              self.message_port_pub(gr.pmt.intern('nmea'), pdu)

          def work(self, input_items, output_items):
              return 0
  states: {}
- name: blocks_null_sink_acq
  id: blocks_null_sink
  parameters:
    comment: 'Acquisition Engine output sink (float: code_phase, doppler, CN0 triplets)'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      OUTPUT — Print NMEA sentences to console
      Shows decoded $GPGGA and $GPRMC strings as they are produced.
      Connect a serial forwarder or pipe to feed nav software.
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: RF Chain
    label1: Correlators & Tracking
    label2: Navigation & Fix
    num_tabs: '3'
  states: {}
- name: qtgui_const_sink_pll
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.5'
    comment: |-
      VISUALISATION — IQ constellation after PLL
      BPSK nav data: should show two clusters at ±Re axis
      Wide spread = poor lock; tight clusters = good tracking
    gui_hint: tabs@1:0,2,1,1
    label1: PLL Output
    name: '"STEP 8: Costas PLL Output (should be BPSK)"'
    size: '1024'
    type: complex
  states: {}

connections:
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_rf, '0']
- [low_pass_filter_0, '0', analog_agc2_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_filtered, '0']
- [analog_agc2_cc_0, '0', qtgui_time_sink_agc, '0']
- [analog_agc2_cc_0, '0', blocks_multiply_cc_0, '0']
- [analog_agc2_cc_0, '0', epy_acquisition, '0']
- [epy_acquisition, '0', blocks_null_sink_acq, '0']
- [epy_prn_generator, '0', blocks_multiply_cc_0, '1']
- [epy_prn_generator, '0', qtgui_time_sink_prn, '0']
- [blocks_multiply_cc_0, '0', blocks_integrate_cc_0, '0']
- [blocks_integrate_cc_0, '0', epy_costas_pll, '0']
- [epy_costas_pll, '0', qtgui_const_sink_pll, '0']
- [epy_costas_pll, '0', epy_dll, '0']
- [epy_dll, '0', epy_nav_bit_decoder, '0']
- [epy_dll, '1', epy_pseudorange_calc, '0']
- [epy_nav_bit_decoder, '0', epy_nav_message_parser, '0']
- [epy_nav_message_parser, ephemeris, epy_pseudorange_calc, ephemeris]
- [epy_pseudorange_calc, pseudorange, epy_position_solver, pseudorange]
- [epy_position_solver, position, epy_nmea_encoder, position]
- [epy_nmea_encoder, nmea, blocks_message_debug_0, print]

metadata:
  file_format: 1
